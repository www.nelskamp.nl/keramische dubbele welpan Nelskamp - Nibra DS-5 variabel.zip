Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: test.ifc
Time: 2011-01-01T11:11:11
Author: Architect
Organization: Building Designer Office
Written by: IFC Engine DLL version 1.03 special version
Made in: example
Authorization: The authorising person

# IfcProject, Default Project
Description: Description of Default Project

# IfcSite, Default Site
Description: Description of Default Site; RefLatitude: 24, 28, 0; RefLongitude: 54, 25, 0; RefElevation: 10 mm

# IfcBuilding, Default Building
Description: Description of Default Building

# IfcBuildingStorey, Default Building Storey
In: Default Building
Description: Description of Default Building Storey; Elevation: 0 mm

# IfcBuildingElementProxy: IFCBUILDINGELEMENTPROXY, keramische dubbele welpan Nelskamp - Nibra DS-5 variabel
In: Default Building Storey
Description: Materiaal; Material: Default Material
BCB_Set_ifcbuildingelementproxy - WUID: AgAAAFEmRgABAAAAVwEAAAVWkAAA1rcAAGKgAAC9bQAAeKwAAAAA; Hyperlink: http://bibliotheek.bouwconnect.nl/index.html?WUID=AgAAAFEmRgABAAAAVwEAAAVWkAAA1rcAAGKgAAC9bQAAeKwAAAAA; breedte: 254 mm; dikte: 7 mm; golfhoogte: 31.5 mm; hoogte: 42.5 mm; lengte: 599 mm; merk: Nelskamp; NL-SfB tabel 3: g9; serie: Nibra DS-5 variabel; werkende breedte: 254 mm; KOMO attest: yes; KOMO productcertificaat: yes; vorstbestendig: yes; soortelijke warmte: 840 j/kg·k; eenheid: st; uurloon: 38 euro
